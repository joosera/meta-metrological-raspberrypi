# Raspberry PI 3 has 4 cores, set to 4 for RPIs
WPE_WEBKITBROWSER_THREADEDPAINTING_raspberrypi3 = "2"
WPE_WEBKITBROWSER_THREADEDPAINTING_raspberrypi3-64 = "2"
