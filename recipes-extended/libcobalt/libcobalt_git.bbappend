COBALT_PLATFORM = "rpi"
COBALT_PLATFORM_NAME = "wpe-${COBALT_PLATFORM}"
