RPIFW_DATE = "20200122"
SRCREV = "01ecfd2ba2b7cf3a2f4aa75ada895ee4a3e729f5"
RPIFW_S = "${WORKDIR}/git"
RPIFW_SRC_URI = "git://github.com/raspberrypi/firmware.git;protocol=git;branch=master"

